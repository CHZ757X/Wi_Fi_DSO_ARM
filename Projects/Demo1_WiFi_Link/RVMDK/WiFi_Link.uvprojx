# Keil uVision project WiFi_Link.uvprojx, settings and files
target WiFi Link@EMW3162 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WiFi_DSO
  AfterMake: fromelf --bin .\Obj\WiFiLink.axf --output ..\Output\WiFiLink.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: EMW3162 USE_STDPERIPH_DRIVER
  c include: ..\..\Demo1_WiFi_Link;..\..\..\HAL;..\..\..\Library;..\..\..\STM32F2xx_StdPeriph_Driver\inc
  asm include: ..\..\..\Demos\Demo1_WiFi_Link
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group startup
    ./startup/: startup_stm32f2xx.s
  group mxchipWNet
    ../../../Library/: mxchipWNet_3162.lib mxchipWNet_3161.lib
  group platform
    ../../../HAL/: system_stm32f2xx.c platform.c
  group Application
    ../../../Demos/Demo1_WiFi_Link/: stm32_GPIO_Config.c main.c stm32f2xx_it.c stm32_fpga_command.c hw_fpga_Communicate.c wificallback.c systemDataStruct.c instructionSet.c channal.c dpx.c acqProcess.c yControl.c scpi_explain.c tControl.c xControl.c unpackfunc.c eeromfunc.c commonfunc.c
    ../: delay_100ns.s
  group STM32_HAL_LIB
    ../../../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_adc.c stm32f2xx_rtc.c stm32f2xx_spi.c stm32f2xx_rng.c
target WiFi Link@EMW3161 (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: as above
  output: WiFiLink
  AfterMake: as above
  c flags: Optim=4
  c define: EMW3161 USE_STDPERIPH_DRIVER
  c include: ..\..\Demo1_WiFi_Link;..\..\..\Library;..\..\..\STM32F2xx_StdPeriph_Driver\inc;..\..\..\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 4.3.0
